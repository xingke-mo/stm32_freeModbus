# IAR project stm32_freeModbus.ewp, settings and files
configuration stm32_freeModbus (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\Third_Party\freemodbus-v1.6\modbus\include; ..\Middlewares\Third_Party\freemodbus-v1.6\demo\stm32\port; ..\..\..\stm32_freeModbus\stm32_freeModbus\Middlewares\Third_Party\freemodbus-v1.6\modbus\rtu; ..\..\..\stm32_freeModbus\stm32_freeModbus\Middlewares\Third_Party\freemodbus-v1.6\modbus\ascii; ..\Drivers\TPUART\include; ..\Middlewares\Third_Party\freemodbus-v1.6\modbus\rtu; ..\Middlewares\Third_Party\freemodbus-v1.6\modbus\ascii; ..\Drivers\NCN5120
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: stm32_freeModbus.hex
  ILINK.IlinkOutputFile: stm32_freeModbus.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Drivers/TPUART/: KnxDevice.c
    ../Middlewares/Third_Party/freemodbus-v1.6/demo/stm32/port/: port.h portevent.c portserial.c porttimer.c
  group Application/User/Core
    ../Core/Src/: crc.c freertos.c gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/NCN5120
    ../Drivers/NCN5120/: ncn5120.c ncn5120.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/TPUART
    ../Drivers/TPUART/: TPUART.c
    ../Drivers/TPUART/include/: TPUART.h
  group Middlewares/FreeModbus
    ../Middlewares/Third_Party/freemodbus-v1.6/modbus/: mb.c
    ../Middlewares/Third_Party/freemodbus-v1.6/modbus/ascii/: mbascii.c mbascii.h
    ../Middlewares/Third_Party/freemodbus-v1.6/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../Middlewares/Third_Party/freemodbus-v1.6/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
